Commit message: funziona planning

File: urdf/robot.urdf (robot description, URDF)
Before this commit: robot m2wr, 12 links, 11 joints
Joints:
- joint joint_laser: origin xyz=0.3 0 0.05 rpy=0 0 0 -> xyz=0.3 0 1 rpy=0 0 0
